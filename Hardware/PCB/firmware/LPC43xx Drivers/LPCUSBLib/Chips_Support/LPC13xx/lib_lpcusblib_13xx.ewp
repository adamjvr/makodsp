# IAR project lib_lpcusblib_13xx.ewp, settings and files
configuration LPC1347_Device (ARM)
  General.OGChipSelectEditMenu: LPC1347 NXP LPC1347
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3; __LPC1347__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: ..\..\..\lpc_core\lpc_ip; ..\..\..\lpc_core\lpc_chip\chip_common; ..\..\..\lpc_core\lpc_chip\chip_13xx; ..\..\..\lpc_core\lpc_board\board_common; ..\..\..\lpc_core\lpc_board\boards_13xx\nxp_xpresso_1347; ..\..\..\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lpc_board.out
  group (top)
    ../../: LPCUSBlibConfig.h
  group Common
    ../../Common/: Attributes.h Common.h CompilerSpecific.h Endianness.h
  group Drivers/USB/Class/Common
    ../../Drivers/USB/Class/Common/: HIDParser.c
  group Drivers/USB/Class/Device
    ../../Drivers/USB/Class/Device/: AudioClassDevice.c CDCClassDevice.c HIDClassDevice.c MassStorageClassDevice.c MIDIClassDevice.c RNDISClassDevice.c
  group Drivers/USB/Class/Host
    ../../Drivers/USB/Class/Host/: AudioClassHost.c CDCClassHost.c HIDClassHost.c MassStorageClassHost.c MIDIClassHost.c PrinterClassHost.c RNDISClassHost.c StillImageClassHost.c
  group Drivers/USB/Core
    ../../Drivers/USB/Core/: ConfigDescriptor.c Device.c DeviceStandardReq.c Endpoint.c EndpointStream.c Events.c Host.c HostStandardReq.c Pipe.c PipeStream.c USBController.c USBMemory.c USBTask.c
  group Drivers/USB/Core/DCD
    ../../Drivers/USB/Core/DCD/LPC11UXX/: Endpoint_LPC11Uxx.c
    ../../Drivers/USB/Core/DCD/LPC17XX/: Endpoint_LPC17xx.c
    ../../Drivers/USB/Core/DCD/LPC18XX/: Endpoint_LPC18xx.c
    ../../Drivers/USB/Core/DCD/USBRom/: usbd_adcuser.c usbd_cdc.c usbd_hid.c usbd_msc.c usbd_rom.c
  group Drivers/USB/Core/HAL
    ../../Drivers/USB/Core/HAL/LPC11UXX/: HAL_LPC11Uxx.c
    ../../Drivers/USB/Core/HAL/LPC17XX/: HAL_LPC17xx.c
    ../../Drivers/USB/Core/HAL/LPC18XX/: HAL_LPC18xx.c
  group Drivers/USB/Core/HCD
    ../../Drivers/USB/Core/HCD/EHCI/: EHCI.c
    ../../Drivers/USB/Core/HCD/: HCD.c
    ../../Drivers/USB/Core/HCD/OHCI/: OHCI.c
