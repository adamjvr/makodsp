# IAR project lib_lpcusblib_18xx_43xx.ewp, settings and files
configuration LPC18xx_Device (ARM)
  General.OGChipSelectEditMenu: LPC1850 NXP LPC1850
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3; __LPC18XX__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: ..\..\..\lpc_core\lpc_ip; ..\..\..\lpc_core\lpc_chip\chip_common; ..\..\..\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\lpc_core\lpc_chip\chip_18xx_43xx\lpc18xx; ..\..\..\lpc_core\lpc_board\board_common; ..\..\..\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330; ..\..\..\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_1830; ..\..\..\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  postbuild: cmd /C copy "$TARGET_PATH$" "$PROJ_FNAME$.a"
  ILINK.IlinkOutputFile: lpc_board.out
configuration LPC18xx_Host (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1830 NXP LPC1830
  ICCARM.CCDefines: CORE_M3; __LPC18XX__; USB_HOST_ONLY
configuration LPC43xx_Device (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  ICCARM.CCDefines: CORE_M4; __LPC43XX__; USB_DEVICE_ONLY
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\lpc_core\lpc_ip; ..\..\..\lpc_core\lpc_chip\chip_common; ..\..\..\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\lpc_core\lpc_chip\chip_18xx_43xx\lpc43xx; ..\..\..\lpc_core\lpc_board\board_common; ..\..\..\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330; ..\..\..\lpc_core\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330; ..\..\..\CMSIS\CMSIS\Include
configuration LPC43xx_Host (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  ICCARM.CCDefines: CORE_M4; __LPC43XX__; USB_HOST_ONLY
  ICCARM.CCIncludePath2: as above
configuration LPC18xx_HostDevice (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1830 NXP LPC1830
  ICCARM.CCDefines: CORE_M3; __LPC18XX__
configuration LPC43xx_HostDevice (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  ICCARM.CCDefines: CORE_M4; __LPC43XX__
  ICCARM.CCIncludePath2: as above
configuration LPC43xx_Device_m0 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M0 NXP LPC4350_M0
  ICCARM.CCDefines: CORE_M0; __LPC43XX__; USB_DEVICE_ONLY
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: as above
  group (top)
    ../../: LPCUSBlibConfig.h
  group Common
    ../../Common/: Attributes.h Common.h CompilerSpecific.h Endianness.h
  group Drivers/USB/Class/Common
    ../../Drivers/USB/Class/Common/: HIDParser.c
  group Drivers/USB/Class/Device
    ../../Drivers/USB/Class/Device/: AudioClassDevice.c CDCClassDevice.c HIDClassDevice.c MassStorageClassDevice.c MIDIClassDevice.c RNDISClassDevice.c
  group Drivers/USB/Class/Host
    ../../Drivers/USB/Class/Host/: AudioClassHost.c CDCClassHost.c HIDClassHost.c MassStorageClassHost.c MIDIClassHost.c PrinterClassHost.c RNDISClassHost.c StillImageClassHost.c
  group Drivers/USB/Core
    ../../Drivers/USB/Core/: ConfigDescriptor.c Device.c DeviceStandardReq.c Endpoint.c EndpointStream.c Events.c Host.c HostStandardReq.c Pipe.c PipeStream.c USBController.c USBMemory.c USBTask.c
  group Drivers/USB/Core/DCD
    ../../Drivers/USB/Core/DCD/LPC11UXX/: Endpoint_LPC11Uxx.c
    ../../Drivers/USB/Core/DCD/LPC17XX/: Endpoint_LPC17xx.c
    ../../Drivers/USB/Core/DCD/LPC18XX/: Endpoint_LPC18xx.c
    ../../Drivers/USB/Core/DCD/USBRom/: usbd_adcuser.c usbd_cdc.c usbd_hid.c usbd_msc.c usbd_rom.c
  group Drivers/USB/Core/HAL
    ../../Drivers/USB/Core/HAL/LPC11UXX/: HAL_LPC11Uxx.c
    ../../Drivers/USB/Core/HAL/LPC17XX/: HAL_LPC17xx.c
    ../../Drivers/USB/Core/HAL/LPC18XX/: HAL_LPC18xx.c
  group Drivers/USB/Core/HCD
    ../../Drivers/USB/Core/HCD/EHCI/: EHCI.c
    ../../Drivers/USB/Core/HCD/: HCD.c
    ../../Drivers/USB/Core/HCD/OHCI/: OHCI.c
