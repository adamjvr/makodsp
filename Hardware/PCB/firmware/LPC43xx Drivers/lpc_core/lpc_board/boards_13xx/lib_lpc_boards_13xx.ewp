# IAR project lib_lpc_boards_13xx.ewp, settings and files
configuration nxp_xpresso_1347 (ARM)
  General.OGChipSelectEditMenu: LPC1347 NXP LPC1347
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..\lpc_ip; ..\..\lpc_chip\chip_common; ..\..\lpc_chip\chip_13xx; ..\..\lpc_board\board_common; ..\..\lpc_board\boards_13xx\nxp_xpresso_1347; ..\..\..\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lpc_board.out
configuration nxp_xpresso_1343 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1343 NXP LPC1343
  ICCARM.CCIncludePath2: ..\..\lpc_ip; ..\..\lpc_chip\chip_common; ..\..\lpc_chip\chip_13xx; ..\..\lpc_board\board_common; ..\..\lpc_board\boards_13xx\nxp_xpresso_1343; ..\..\..\CMSIS\CMSIS\Include
  ICCARM.CCOptStrategy: 0
  group board_nxp_xpresso_1343
    nxp_xpresso_1343/: board_nxp_xpresso_1343.c sysinit_nxp_xpresso_1343.c
  group board_nxp_xpresso_1347
    nxp_xpresso_1347/: board_nxp_xpresso_1347.c sysinit_nxp_xpresso_1347.c
  group chip_13xx
    ../../lpc_chip/chip_13xx/: adc_13xx.c clock_13xx.c flash_13xx.c gpio_13xx.c i2c_13xx.c iocon_13xx.c ritimer_13xx.c ssp_13xx.c sysctl_13xx.c timer_13xx.c uart_13xx.c wwdt_13xx.c
    ../../lpc_chip/chip_common/: ring_buffer.c
  group ip
    ../../lpc_ip/: adc_001.c gpio_003.c gpiogrpint_001.c gpiopinint_001.c i2c_001.c ritimer_001.c ssp_001.c timer_001.c usart_004.c wwdt_001.c
