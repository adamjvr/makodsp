# IAR project lib_lpc_boards_17xx_40xx.ewp, settings and files
configuration ea_devkit_1788 (ARM)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..\lpc_ip; ..\..\lpc_chip\chip_common; ..\..\lpc_chip\chip_17xx_40xx; ..\..\lpc_board\board_common; ..\..\lpc_board\boards_17xx_40xx\ea_devkit_17884088; ..\..\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_1788; ..\..\..\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lpc_board.out
configuration ea_devkit_4088 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCIncludePath2: ..\..\lpc_ip; ..\..\lpc_chip\chip_common; ..\..\lpc_chip\chip_17xx_40xx; ..\..\lpc_board\board_common; ..\..\lpc_board\boards_17xx_40xx\ea_devkit_17884088; ..\..\lpc_board\boards_17xx_40xx\ea_devkit_17884088\ea_devkit_4088; ..\..\..\CMSIS\CMSIS\Include
configuration nxp_xpresso_1769 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1769 NXP LPC1769
  ICCARM.CCIncludePath2: ..\..\lpc_ip; ..\..\lpc_chip\chip_common; ..\..\lpc_chip\chip_17xx_40xx; ..\..\lpc_board\board_common; ..\..\lpc_board\boards_17xx_40xx\nxp_xpresso_1769; ..\..\..\CMSIS\CMSIS\Include
  group board_ea_devkit_17884088
    ea_devkit_17884088/: board_ea_devkit_17884088.c sysinit_ea_devkit_17884088.c
    ../board_common/: uda1380.c
  group board_nxp_xpresso_1769
    nxp_xpresso_1769/: board_nxp_xpresso_1769.c sysinit_nxp_xpresso_1769.c
  group chip_17xx_40xx
    ../../lpc_chip/chip_17xx_40xx/: adc_17xx_40xx.c can_17xx_40xx.c clock_17xx_40xx.c cmp_17xx_40xx.c crc_17xx_40xx.c dac_17xx_40xx.c eeprom_17xx_40xx.c emc_17xx_40xx.c enet_17xx_40xx.c gpdma_17xx_40xx.c i2c_17xx_40xx.c i2s_17xx_40xx.c iocon_17xx_40xx.c lcd_17xx_40xx.c ritimer_17xx_40xx.c rtc_17xx_40xx.c sdc_17xx_40xx.c sdmmc_17xx_40xx.c spi_17xx_40xx.c ssp_17xx_40xx.c sysctl_17xx_40xx.c timer_17xx_40xx.c uart_17xx_40xx.c wwdt_17xx_40xx.c
    ../../lpc_chip/chip_common/: mem_tests.c
  group ip
    ../../lpc_ip/: adc_001.c can_001.c crc_001.c dac_001.c eeprom_001.c emc_001.c enet_002.c fpu_init.c gpdma_001.c i2c_001.c i2s_001.c lcd_001.c ritimer_001.c rtc_001.c sdc_001.c ssp_001.c timer_001.c usart_001.c wwdt_001.c
