# IAR project lib_lpc_boards_18xx_43xx.ewp, settings and files
configuration ngx_xplorer_1830 (ARM)
  General.OGChipSelectEditMenu: LPC1830 NXP LPC1830
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M3
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..\lpc_ip; ..\..\lpc_chip\chip_common; ..\..\lpc_chip\chip_18xx_43xx; ..\..\lpc_board\board_common; ..\..\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330; ..\..\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_1830; ..\..\..\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  postbuild: cmd /C copy "$TARGET_PATH$" "$PROJ_FNAME$.a"
  ILINK.IlinkOutputFile: lpc_board.out
configuration ngx_xplorer_4330 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4330_M4 NXP LPC4330_M4
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCIncludePath2: ..\..\lpc_ip; ..\..\lpc_chip\chip_common; ..\..\lpc_chip\chip_18xx_43xx; ..\..\lpc_board\board_common; ..\..\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330; ..\..\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330; ..\..\..\CMSIS\CMSIS\Include
  ICCARM.CCOptStrategy: 2
configuration ngx_xplorer_4330_m0 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4330_M0 NXP LPC4330_M0
  ICCARM.CCDefines: CORE_M0
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 2
configuration keil_mcb_1857 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1857 NXP LPC1857
  ICCARM.CCIncludePath2: ..\..\lpc_ip; ..\..\lpc_chip\chip_common; ..\..\lpc_chip\chip_18xx_43xx; ..\..\lpc_board\board_common; ..\..\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_1857; ..\..\..\CMSIS\CMSIS\Include
  ICCARM.CCOptStrategy: 2
configuration keil_mcb_4357 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCIncludePath2: ..\..\lpc_ip; ..\..\lpc_chip\chip_common; ..\..\lpc_chip\chip_18xx_43xx; ..\..\lpc_board\board_common; ..\..\lpc_board\boards_18xx_43xx\keil_mcb_18574357; ..\..\lpc_board\boards_18xx_43xx\keil_mcb_18574357\keil_mcb_4357; ..\..\..\CMSIS\CMSIS\Include
  ICCARM.CCOptStrategy: 2
configuration keil_mcb_4357_m0 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4357_M0 NXP LPC4357_M0
  ICCARM.CCDefines: CORE_M0
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 2
configuration hitex_eva_1850 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1850 NXP LPC1850
  ICCARM.CCIncludePath2: ..\..\lpc_ip; ..\..\lpc_chip\chip_common; ..\..\lpc_chip\chip_18xx_43xx; ..\..\lpc_board\board_common; ..\..\lpc_board\boards_18xx_43xx\hitex_eva_18504350; ..\..\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_1850; ..\..\..\CMSIS\CMSIS\Include
  ICCARM.CCOptStrategy: 2
configuration hitex_eva_4350 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCIncludePath2: ..\..\lpc_ip; ..\..\lpc_chip\chip_common; ..\..\lpc_chip\chip_18xx_43xx; ..\..\lpc_board\board_common; ..\..\lpc_board\boards_18xx_43xx\hitex_eva_18504350; ..\..\lpc_board\boards_18xx_43xx\hitex_eva_18504350\hitex_eva_4350; ..\..\..\CMSIS\CMSIS\Include
  ICCARM.CCOptStrategy: 2
configuration hitex_eva_4350_m0 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M0 NXP LPC4350_M0
  ICCARM.CCDefines: CORE_M0
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 2
  group board_common
    ../board_common/: uda1380.c
  group board_hitex_eva_18504350
    hitex_eva_18504350/: board_hitex_eva_18504350.c sysinit_hitex_eva_18504350.c
  group board_keil_mcb_18574357
    keil_mcb_18574357/: board_keil_mcb_18574357.c sysinit_keil_mcb_18574357.c
  group board_ngx_xplorer_18304330
    ngx_xplorer_18304330/: board_ngx_xplorer_18304330.c sysinit_ngx_xplorer_18304330.c
  group chip_18xx43xx
    ../../lpc_chip/chip_18xx_43xx/: adc_18xx_43xx.c aes_18xx_43xx.c atimer_18xx_43xx.c ccan_18xx_43xx.c clock_18xx_43xx.c dac_18xx_43xx.c eeprom_18xx_43xx.c emc_18xx_43xx.c enet_18xx_43xx.c evrt_18xx_43xx.c gpdma_18xx_43xx.c gpio_18xx_43xx.c i2c_18xx_43xx.c i2s_18xx_43xx.c lcd_18xx_43xx.c otp_18xx_43xx.c pmc_18xx_43xx.c rgu_18xx_43xx.c ritimer_18xx_43xx.c rtc_18xx_43xx.c sct_18xx_43xx.c scu_18xx_43xx.c sdif_18xx_43xx.c sdmmc_18xx_43xx.c ssp_18xx_43xx.c timer_18xx_43xx.c uart_18xx_43xx.c wwdt_18xx_43xx.c
  group ip
    ../../lpc_ip/: adc_001.c atimer_001.c ccan_001.c dac_001.c eeprom_002.c emc_001.c enet_001.c fpu_init.c gpdma_001.c gpioint_001.c gpiopinint_001.c i2c_001.c i2s_001.c lcd_001.c ritimer_001.c rtc_001.c sct_001.c sdmmc_001.c ssp_001.c timer_001.c usart_001.c wwdt_001.c
